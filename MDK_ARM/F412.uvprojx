# Keil uVision project F412.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F412RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F412
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F412xG
  c include: ..\CMSIS\Include;..\CMSIS\Device\Include;..\APP;..\Library\STM32F4xx_StdPeriph_Driver\inc;..\Core;..\Library;..\Arduino_API;..\Arduino_API\avr;..\Library\cm_backtrace;..\Library\cm_backtrace\Languages\zh-CN;..\Library\HAL
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group APP
    ../APP/: stm32f4xx_it.c main.cpp
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c
  group Startup
    ../CMSIS/Startup/arm/: startup_stm32f412xg.s
  group Core
    ../Core/: adc.c delay.c exti.c flash.c gpio.c pwm.c rng.c timer.c
  group Std_Driver
    ../Library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_exti.c
  group Arduino
    ../Arduino_API/: Arduino.c HardwareSerial.cpp Print.cpp Stream.cpp dtostrf.c itoa.c Wire.cpp WireBase.cpp WMath.cpp WString.cpp
  group cm_backtrace
    ../Library/cm_backtrace/: cm_backtrace.c cm_backtrace.h cmb_cfg.h cmb_def.h fault_test.c
    ../Library/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group Library
    ../Library/MillisTaskManager/: MillisTaskManager.cpp
  group HAL
    ../Library/HAL/: HAL.cpp
software components: CMSIS:CORE 5.5.0
